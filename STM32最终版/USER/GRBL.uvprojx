# Keil uVision project GRBL.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GRBL +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\STM32F10x_FWLib\inc;..\CORE;..\USER;..\SYSTEM\sys;..\SYSTEM\usart;..\SYSTEM\i2c;..\SYSTEM\adc;..\SYSTEM\systick;..\SYSTEM\outputdata;..\SYSTEM\dac;..\SYSTEM\flash;..\SYSTEM\rtc;..\SYSTEM\delay;..\HARDWARE\LED;..\HARDWARE\SYN6288;..\HARDWARE\MPU6050;..\HARDWARE\ESP8266;..\HARDWARE\MOTOR;..\HARDWARE\STEERING;..\HARDWARE\STEPPING;..\HARDWARE\OLED;..\HARDWARE\ULTRASOUND;..\HARDWARE\HMI;..\HARDWARE\HMC5883L;..\HARDWARE\PCF8591;..\HARDWARE\BOOM
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SYN6288/: syn6288.c
    ../HARDWARE/MPU6050/: mpu6050.c
    ../HARDWARE/ESP8266/: esp8266.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/STEERING/: steering.c
    ../HARDWARE/STEPPING/: stepping.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/ULTRASOUND/: ultrasound.c
    ../HARDWARE/HMI/: hmi.c
    ../HARDWARE/HMC5883L/: hmc5883l.c
    ../HARDWARE/PCF8591/: pcf8591.c
    ../HARDWARE/BOOM/: boom.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/adc/: adc.c
    ../SYSTEM/i2c/: i2c.c
    ../SYSTEM/systick/: systick.c
    ../SYSTEM/outputdata/: outputdata.c
    ../SYSTEM/dac/: dac.c
    ../SYSTEM/rtc/: rtc.c
    ../SYSTEM/flash/: flash.c
    ../SYSTEM/delay/: delay.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_pwr.c stm32f10x_bkp.c stm32f10x_dac.c stm32f10x_rtc.c stm32f10x_flash.c
software components: CMSIS:CORE 5.0.1
